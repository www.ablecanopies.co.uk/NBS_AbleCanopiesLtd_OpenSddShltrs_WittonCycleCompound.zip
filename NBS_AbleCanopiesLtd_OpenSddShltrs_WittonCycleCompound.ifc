Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2020-04-30T17:12:59
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190510_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013* Module: EDMstepFileFactory/EDMstandAlone* Creation date: Thu Apr 30 17:12:59 2020* Host: NCL-PI19* Database: C:\Users\MatukiNE\AppData\Local\Temp\{7D5C4289-CB4B-4FA7-9F80-6D4432EE4C78}\ifc* Database version: 5507* Database creation date: Thu Apr 30 17:12:58 2020* Schema: IFC2X3* Model: DataRepository.ifc* Model creation date: Thu Apr 30 17:12:58 2020* Header model: DataRepository.ifc_HeaderModel* Header model creation date: Thu Apr 30 17:12:58 2020* EDMuser: sdai-user* EDMgroup: sdai-group* License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: WittonCycleCompound, NBS_AbleCanopiesLtd_OpenSddShltrs_WittonCycleCompound:WittonCycleCompound:192180
In: Level 1
Type - PredefinedType: USERDEFINED; Classification: Pr_40_30_21_84 (Uniclass2015); Material: NBS_Concept, NBS_Plastic_Clear
Type - BOS_General - Author: NBS; BIMObjectName: NBS_AbleCanopiesLtd_OpenSidedShelters_WittonCycleCompound; ManufacturerName: Able Canopies Ltd; ManufacturerURL: www.ablecanopies.co.uk; NBSCertification: www.nationalbimlibrary.com/cert/44evfyqw; NBSDescription: Stainless steel cycle stands; NBSReference: 45-35-86/303; ProductInformation: https://www.ablecanopies.co.uk/shelters/cycle-compounds/witton-cycle-compound.html; Revision: n/a; Uniclass2015Title: Stainless steel cycle stands; Uniclass2015Code: Pr_40_30_21_84; Uniclass2015Version: Products v1.17; Version: 1
Type - NBS_Data - FrameMaterial: NBS_Concept; FrameFinish: Powder coated; FrameColour: www.ablecanopies.co.uk/ral-colour-options.html; RoofCovering: Polycarbonate sheets; StandType: Cycle; NumberOfStands: A standard compounds has 10 stands and stores 20 bikes; Base: Requires a concrete base; IntegralServices: n/a; RainwaterDrainage: n/a; Accessories: n/a; MaximumLength: 4000 mm as standard (can be extended by 2000 mm bays); WeatherResistance: UV absorber is co-extruded to surface; FireRating: Sheets are stable at very high temperatures
Type - Pset_FurnitureTypeCommon - NominalDepth: 0 mm; Description: Cycle Compound is constructed from steel box sections and is covered enclosed with polycarbonates panels; MainColor: n/a; NominalHeight: 2900 mm; NominalLength: 4000 mm; Style: Cycle shelter
Type - IFC - IfcExportAs: IfcBuildingElementProxyType; IfcExportType: USERDEFINED
Type - COBie - AccessibilityPerformance: n/a; AssetType: Fixed; Category: Pr_40_30_21_84; Stainless steel cycle stands; CodePerformance: n/a; Color: www.ablecanopies.co.uk/colours-finishes.html; Constituents: n/a; DurationUnit: year; ExpectedLife: 25 years; Features: n/a; Finish: n/a; Grade: n/a; Manufacturer: sales@ablecanopies.co.uk; Material: n/a; ModelNumber: n/a; ModelReference: Witton Cycle Compound; Name: OpenSidedShelters_WittonCycleCompound_AbleCanopiesLtd; NominalWidth: 6600 mm; ReplacementCost: n/a; Shape: n/a; Size: 50 x 50 x 2.5 mm; SustainabilityPerformance: n/a; WarrantyDescription: 10 years; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
COBie - Category: Generic Models; AssetIdentifier: n/a; BarCode: n/a; InstallationDate: 1900-12-31T23:59:59; SerialNumber: n/a; TagNumber: n/a; WarrantyStartDate: 1900-12-31T23:59:59
